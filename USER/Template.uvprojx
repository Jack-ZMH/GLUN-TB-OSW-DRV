# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --C99
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CORE;..\HALLIB\Inc;..\HALLIB\Inc\Legacy;..\USER;..\HARDWARE\ADC;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\CORE;..\HARDWARE\IIC;..\HARDWARE\AD517x;..\HARDWARE\NXP9868;..\HARDWARE\UART_CMD;..\HARDWARE\MIxN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c cmd_logictable.c
    ../HALLIB/Src/: stm32f4xx_hal_sram.c stm32f4xx_ll_sdmmc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f411xe.s
  group HALLIB
    ../HALLIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_sd.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dsi.c stm32f4xx_hal_dma.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ./: bsp_i2c.c
    ../HARDWARE/AD517x/: ad517x_lib.c
    ../HARDWARE/NXP9868/: bsp_nxp9698.c
    ../HARDWARE/IIC/: i2c_device.c
    ../HARDWARE/UART_CMD/: uart_cmd.c
    ../HARDWARE/MIxN/: bsp_MxN.c bsp_C1X2G.c bsp_D2X2B.c bsp_M1X4.c bsp_S1X4.c bsp_S1X8.c
